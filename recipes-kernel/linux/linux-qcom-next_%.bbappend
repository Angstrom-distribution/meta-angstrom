# Distro-wide baseline kernel config (nftables, containers, IWD, zram)
require recipes-kernel/linux/angstrom-kernel-features.inc
