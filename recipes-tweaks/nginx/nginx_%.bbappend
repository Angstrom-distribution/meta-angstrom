EXTRA_OECONF_append = " \
                       --with-http_v2_module \
                       --with-http_stub_status_module \
                       --with-stream \
                      "
