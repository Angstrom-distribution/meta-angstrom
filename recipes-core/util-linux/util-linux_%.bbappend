# Enable the fstrim timer
SYSTEMD_AUTO_ENABLE:${PN}-fstrim:angstrom = "enable" 
