PACKAGECONFIG = "sensors libatasmart"
