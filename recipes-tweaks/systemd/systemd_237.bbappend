FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"

SRC_URI += "file://6f130e85c76cfc2c58ba31f90d2ac3800866c1dd.patch"
