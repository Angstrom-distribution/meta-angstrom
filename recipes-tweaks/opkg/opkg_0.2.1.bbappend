FILESEXTRAPATHS_prepend := "${THISDIR}/files:"


SRC_URI_append = " file://0001-pkg_hash-prevent-debug-spew-for-ignored-packages.patch "
