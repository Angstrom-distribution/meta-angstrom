inherit gettext

