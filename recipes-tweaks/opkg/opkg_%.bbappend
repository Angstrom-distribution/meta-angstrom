# busybox wget doesn't understand https :(

RDEPENDS_${PN} += "wget"
