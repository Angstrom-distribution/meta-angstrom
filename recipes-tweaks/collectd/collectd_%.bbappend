PACKAGECONFIG_append_angstrom = " iptables libatasmart snmp sensors"
