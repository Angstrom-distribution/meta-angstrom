KORG_ARCHIVE_COMPRESSION = "xz"

require linux-libc-headers.inc

SRC_URI[md5sum] = "b4ff3e1d591f7464e678c43d421c85fc"
SRC_URI[sha256sum] = "df27f4dd3b2657fb29d76af2190289f54fb651b82d2bcd225aa846973a22f421"

