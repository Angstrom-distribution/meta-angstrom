DEPENDS_append = " libgudev"
