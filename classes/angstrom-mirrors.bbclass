PREMIRRORS_append () {
cvs://.*/.* http://sources.angstrom-distribution.org/v2012.12/
svn://.*/.* http://sources.angstrom-distribution.org/v2012.12/
git://.*/.* http://sources.angstrom-distribution.org/v2012.12/
hg://.*/.*  http://sources.angstrom-distribution.org/v2012.12/
bzr://.*/.* http://sources.angstrom-distribution.org/v2012.12/
osc://.*/.* http://sources.angstrom-distribution.org/v2012.12/
p4://.*/.*  http://sources.angstrom-distribution.org/v2012.12/
svk://.*/.* http://sources.angstrom-distribution.org/v2012.12/
}

MIRRORS_append () {
ftp://.*/.*	http://sources.angstrom-distribution.org/v2012.12/
https?$://.*/.*	http://sources.angstrom-distribution.org/v2012.12/
}
