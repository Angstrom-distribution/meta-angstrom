PACKAGECONFIG = "orc"

inherit autotools-brokensep

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

