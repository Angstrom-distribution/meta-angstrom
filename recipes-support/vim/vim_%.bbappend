# Don't drag in gtk3 just for vim
PACKAGECONFIG:remove = "gtkgui"
