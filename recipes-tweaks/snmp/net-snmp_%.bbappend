DEPENDS_append = " lmsensors"
PACKAGECONFIG_append = " elfutils libnl ipv6"
