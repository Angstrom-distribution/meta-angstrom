#PV = "1.7.4+giti${SRCPV}"

#SRCREV = "d4ec7aa1e550b1e604cafa3080d43fd49e99c0cf"

CONFFILES_${PN} += "${sysconfdir}/accel-ppp.conf"

