require linux-libc-headers.inc

SRC_URI[md5sum] = "fe3487940018bacda66ac57f60ee36b9"
SRC_URI[sha256sum] = "c10c7f81019bd782ea77a25725f6d53e9affa4a0cfd3985c161f3a2a22f2df73"
